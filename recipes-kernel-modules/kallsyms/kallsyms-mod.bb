LICENSE = "CLOSED"

inherit module

SRC_URI = "file://Makefile \
           file://kallsyms-mod.c \
          "

S = "${WORKDIR}"
