LICENSE = "CLOSED"
inherit module
SRC_URI = "file://Makefile \
           file://ttyw-mod.c \
          "
S = "${WORKDIR}"
