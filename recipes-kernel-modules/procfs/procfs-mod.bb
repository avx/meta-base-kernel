LICENSE = "CLOSED"
inherit module

SRC_URI = "file://Makefile \
           file://procfs.c \
          "

S = "${WORKDIR}"
