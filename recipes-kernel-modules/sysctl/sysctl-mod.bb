LICENSE = "CLOSED"

inherit module

SRC_URI = "file://Makefile \
           file://sysctl-mod.c \
          "

S = "${WORKDIR}"
